# IAR project Backup of gpio_ex4_writeToPort1.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\driverlib\driverlib\MSP430FR2xx_4xx; ..\OLED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr4133.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: gpio_ex4_writeToPort1.c
  group driverlib/MSP430FR2xx_4xx
    ../../../driverlib/driverlib/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h ecomp.c ecomp.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_e.c lcd_e.h mpy32.c mpy32.h pmm.c pmm.h rtc.c rtc.h sac.c sac.h sfr.c sfr.h sysctl.c sysctl.h tia.c tia.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../../../driverlib/driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
  group driverlib/OLED
    ../OLED/: font_char.h font_chinese.h oled.c oled.h oled_iic.h oledfont.h
